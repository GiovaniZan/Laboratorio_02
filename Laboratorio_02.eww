<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Exercicio10\Exercicio10.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Exercicio11\Exercicio11.ewp</path>
    </project>
    <batchBuild />
</workspace>
